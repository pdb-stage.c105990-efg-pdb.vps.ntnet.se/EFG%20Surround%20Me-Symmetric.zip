Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_EFG_EFG-Surround-Me-Symmetric.ifc
Time: 2021-06-02T12:28:03
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: EFG Surround Me - Symmetric
ePset_BIMobjectScript - Type: Writing board for sofa; Roof: On; Electricity: On; Lamp: On; Shell and Roof Color: Beige - Fabric; Sofa Color: Beige - Fabric; Table Color: Ash White; Legs Color: Ash White; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EFG Surround Me - Symmetric; SKU (BO_prodsku): SURSS; ManufacturName (BO_Manufac): EFG; BrandUrl (BO_brandurl): http://www.efg.se; ProductFamily (BO_prodfam): EFG Surround; ProductGroup (BO_prodgroup): ME; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 12/9/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/efg/product/SURSS; ProductDataUrl (BO_prodaturl): bimobject.com/efg/product/SURSS; ProductUrl (BO_producturl): http://www.efg.info/Products/Screening--Acoustics/EFG-Surround?filter=Screening; InstallationInstructions (BO_montins): http://www.efg.info/Products/Screening--Acoustics/EFG-Surround?tab=Downloads; ProductCertification (BO_prodcert): http://www.efg.info/Products/Screening--Acoustics/EFG-Surround?tab=Downloads; TechnicalDescription (BO_techcert): http://www.efg.info/Products/Screening--Acoustics/EFG-Surround?tab=Downloads; MaterialMain (BO_mainmat): Wood; MaterialSecondary (BO_secmat): Fabric; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): furniture-chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): PR-31-12; Uniclass20Description (BO_uniclass_2_0_desc): Chairs, Seats And Bench Seating; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; OmniClassCode (BO_omniclass_code): 23-21 00 00; OmniClassDescription (BO_omniclass_name): Furnishings, Fixtures and Equipment Products; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; UniFormat2Code (BO_uniformat2_code): E2020; UniFormat2Description (BO_uniformat2_name): Movable Furnishings; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
